# Keil uVision project lv_template.uvprojx, settings and files
target Cortex-M55_MPS3 (6170000::V6.17::.\ARMCompiler6.17)
  device: SSE-300-MPS3 ARM
  pack: ARM.V2M_MPS3_SSE_300_BSP.1.2.0
  cpu: IRAM(0x00000000,0x00080000) IRAM2(0x01000000,0x00200000) XRAM(0x20000000,0x00020000) XRAM2(0x20020000,0x00020000) XRAM3(0x20040000,0x00020000) CPUTYPE("Cortex-M55") FPU3(DFPU) DSP TZ MVE(FP) CLOCK(12000000) ESEL ELITTLE
  output: lv_template
  c flags: OneElfS=1 v6Lang=6 v6LangP=3 v6Lto=1 wLevel=3
  c define: COMPILER_FLAGS=\"-Omax\"
  c misc: -Wno-format -Omax
  c include: .\platform;.;.\coremark;.\coremark\simple
  library: MicroLIB
  memory RVCT6: RAM 0x20000000 size 0x20000
  memory RVCT7: RAM 0x20020000 size 0x20000
  memory RVCT8: RAM 0x20040000 size 0x20000
  memory RVCT9: RAM 0x0 size 0x80000
  memory RVCT10: RAM 0x1000000 size 0x200000
  scatter file: .\RTE\Device\SSE-300-MPS3\fvp_sse300_mps3_s.sct
  link misc: --diag_suppress=6314
  group platform
    ./platform/: serial.c serial.h platform.c platform.h
  group Documentation
    ./: Abstract.txt
  group application
    ./: main.c app_cfg.h
  group Coremark
    ./coremark/simple/: core_portme.c core_portme.h
    ./coremark/: core_list_join.c core_main.c core_matrix.c core_state.c core_util.c coremark.h
software components: CMSIS Driver:USART 1.0.0, CMSIS:CORE 5.5.0, Device:Definition 1.1.0, Device:Startup 1.1.0, Native Driver:SysCounter 1.0.0, Native Driver:SysTimer 1.0.0, Native Driver:Timeout 1.0.0, Native Driver:UART 1.0.0, Utilities:perf_counter:Core 1.9.3, Compiler:Event Recorder 1.4.0, Compiler:I/O:STDOUT 1.2.0
