# Keil uVision project gcc_template.uvprojx, settings and files
target Cortex-M55_MPS3 (6160000::V6.16::ARMCLANG)
  device: SSE-300-MPS3 ARM
  pack: ARM.V2M_MPS3_SSE_300_BSP.1.2.0
  cpu: IRAM(0x00000000,0x00080000) IRAM2(0x01000000,0x00200000) XRAM(0x20000000,0x00020000) XRAM2(0x20020000,0x00020000) XRAM3(0x20040000,0x00020000) CPUTYPE("Cortex-M55") FPU3(DFPU) DSP TZ MVE(FP) CLOCK(12000000) ESEL ELITTLE
  output: gcc_template
  AfterMake: arm-none-eabi-size.exe ./Objects/gcc_template.elf
  group platform
    ./platform/: platform.c platform.h serial.c serial.h perf_counter.c perf_counter.h
  group device
    ./RTE/Device/SSE-300-MPS3/: cmsis_driver_config.h device_cfg.h platform_base_address.h region_defs.h region_limits.h RTE_Device.h startup_fvp_sse300_mps3.c system_SSE300MPS3.c gcc_arm.ld
  group Coremark
    ./coremark/: core_list_join.c core_main.c core_matrix.c core_state.c core_util.c coremark.h
    ./coremark/simple/: core_portme.c core_portme.h
    ./: app_cfg.h
software components: CMSIS:CORE 5.5.0, Compiler:Event Recorder 1.4.0
